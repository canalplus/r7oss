## G9/src/armbcm-linux-sources-3.14.28.1.14_p14/linux/drivers/soc/Kconfig
```kconfig
menu "SOC (System On Chip) specific Drivers"

source "drivers/soc/brcmstb/Kconfig"

endmenu
```
